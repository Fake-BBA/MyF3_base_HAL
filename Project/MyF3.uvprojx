# Keil uVision project MyF3.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303CCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MyF3
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC
  c include: ..\USER\Inc;..\Devices\Drivers\Inc;..\Devices\HardWare\Inc;..\System\Core\Inc;..\System\Dev\Inc;..\System\Hal_Lib\Inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Hal_Src
    ../System/Hal_Lib/Src/: stm32f3xx_hal.c stm32f3xx_hal_gpio.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_usart.c
  group User
    ../USER/Src/: main.c stm32f3xx_it.c stm32f3xx_hal_msp.c system_stm32f3xx.c Attitude.c
    ../USER/Inc/: stm32f3xx_it.h Devices.h MyConfiguration.h MyTypedef.h Attitude.h
    ../: ReadMe.txt
  group Core
    ../System/Dev/: startup_stm32f303xc.s
    ../System/Core/Inc/: cmsis_armcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group Drivers
    ../Devices/Drivers/Src/: Dri_Buzzer.c Dri_HMC5883L.c Dri_LED.c Dri_MPU6050.c Dri_MS5611.c Dri_Uart.c Dri_W25Q64.c
    ../Devices/HardWare/Src/: Dri_SysTick.h.c
    ../Devices/Drivers/Inc/: Dri_W25Q64.h Dri_Uart.h Dri_MS5611.h Dri_MPU6050.h Dri_LED.h Dri_HMC5883L.h Dri_Buzzer.h Dri_SysTick.h
  group HardWare
    ../Devices/Drivers/Src/: Har_SysTick.c
    ../Devices/HardWare/Inc/: Har_LED.h Har_Buzzer.h Har_HMC5883L.h Har_MPU6050.h Har_MS5611.h Har_Uart.h Har_W25Q64.h Har_stm32_dma.h Har_SysTick.h Har_I2C.h
    ../Devices/HardWare/Src/: Har_LED.c Har_Buzzer.c Har_HMC5883L.c Har_MPU6050.c Har_MS5611.c Har_Uart.c Har_W25Q64.c Har_stm32_dma.c Har_I2C.c
